Commit message: rllib

File: data/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link cubeLink: geometry collision box size=0.3 0.3 0.3; visual mesh filename=cube.obj scale=0.3 0.3 0.3
