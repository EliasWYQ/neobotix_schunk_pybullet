Commit message: roha add ray

File: data/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planelink: geometry collision box size=30 30 10; visual mesh filename=plane.obj scale=2 2 2
